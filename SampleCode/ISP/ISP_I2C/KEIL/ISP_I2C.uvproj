# Keil uVision project ISP_I2C.uvproj, settings and files
target ISP_I2C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NANO103SD3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ISP_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano103.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group User
    ../: main.c FMC_USER.c ISP_USER.c i2c_transfer.c
