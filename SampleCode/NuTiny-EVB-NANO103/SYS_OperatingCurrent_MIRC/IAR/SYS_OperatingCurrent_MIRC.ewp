# IAR project SYS_OperatingCurrent_MIRC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano103AN series Nuvoton Nano103AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\library\Device\Nuvoton\Nano103\Include; $PROJ_DIR$..\..\..\..\..\library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_OperatingCurrent_MIRC.bin
  ILINK.IlinkOutputFile: SYS_OperatingCurrent_MIRC.out
  ILINK.IlinkIcfFile: SYS_OperatingCurrent_MIRC.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/Nano103/Source/IAR/: startup_Nano103.s
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
    ../: programcounter_test.c
  group Source Files
    ../: main.c
