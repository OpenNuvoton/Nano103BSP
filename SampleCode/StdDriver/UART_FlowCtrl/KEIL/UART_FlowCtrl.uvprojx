# Keil uVision project UART_FlowCtrl.uvprojx, settings and files
target UART_FlowCtrl (6150000::V6.15::ARMCLANG)
  device: NANO103SD3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: UART
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano103.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group User
    ../: main.c
  group Libraries
    ../../../../Library/StdDriver/src/: sys.c clk.c uart.c retarget.c
