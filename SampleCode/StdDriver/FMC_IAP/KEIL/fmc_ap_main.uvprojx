# Keil uVision project fmc_ap_main.uvprojx, settings and files
target APROM_main (6120000::V6.12::.\ARMCLANG)
  device: NANO103SD3AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: FMC_RW
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\..\Library\StdDriver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano103.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group Libraries
    ../../../../Library/StdDriver/src/: sys.c clk.c retarget.c fmc.c uart.c
  group User
    ../: APROM_main.c
    ./: ap_image.s
