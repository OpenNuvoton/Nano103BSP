# IAR project DSRC_Control.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano103AN series Nuvoton Nano103AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\library\Device\Nuvoton\Nano103\Include; $PROJ_DIR$..\..\..\..\..\library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DSRC_Control.bin
  ILINK.IlinkOutputFile: DSRC_Control.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../Device/IAR/: startup_Nano103.s
    ../../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c dsrc.c gpio.c retarget.c spi.c sys.c uart.c
  group Source Files
    ../: main.c RF_module.c sky6605_function.c
