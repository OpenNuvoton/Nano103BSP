# Keil uVision project i2c.uvproj, settings and files
target i2c (ARM-ADS)
  device: (Generic) Nano100 Series Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: i2c
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\Library\StdDriver\inc;..\..\common\inc
  asm define: Stack_Size=0xa00, Heap_Size=0x500
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group User
    ../: main.c i2c_cunit.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c clk.c i2c.c sys.c uart.c
    ../../common/: CUnitTestM0.lib
