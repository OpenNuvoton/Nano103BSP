# Keil uVision project pwm.uvproj, settings and files
target pwm (ARM-ADS)
  device: NANO103SD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: pwm
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\common\inc
  asm define: Stack_Size=0x600, Heap_Size=0x600
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano103.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group User
    ../: main.c pwm_cunit.c
  group Library
    ../../common/: CUnitTestM0.lib
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c pwm.c gpio.c
