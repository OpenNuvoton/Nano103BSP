# Keil uVision project sys_cunit.uvproj, settings and files
target sys_cunit (ARM-ADS)
  device: NANO103SD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: sys_cunit
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: OPTION=7
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\Library\StdDriver\inc;..\..\common\inc
  asm define: Stack_Size=0x500, Heap_Size=0x400
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_Nano103.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group User
    ../: main.c sys_cunit.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c
    ../../common/: CUnitTestM0.lib
