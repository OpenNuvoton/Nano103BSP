# Keil uVision project spi_cunit_MacroTest.uvproj, settings and files
target spi_cunit_MacroTest (ARM-ADS)
  device: (Generic) Nano100 Series Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: spi_cunit_MacroTest
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: MACRO_TEST
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\Nano103\Include;..\..\..\Library\StdDriver\inc;..\..\common\inc
  asm define: Stack_Size=0xA00, Heap_Size=0xA00
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano103/Source/: system_Nano103.c
    ../../../Library/Device/Nuvoton/Nano103/Source/ARM/: startup_Nano103.s
  group User
    ../: main.c spi_cunit.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c spi.c clk.c sys.c uart.c
    ../../common/: CUnitTestM0.lib
